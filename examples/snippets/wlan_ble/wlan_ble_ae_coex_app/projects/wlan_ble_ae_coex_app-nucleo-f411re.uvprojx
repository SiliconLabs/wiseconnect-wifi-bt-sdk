# Keil uVision project wlan_ble_ae_coex_app-nucleo-f411re.uvprojx, settings and files
target wlan_ble_ae_coex_app (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: wlan_ble_ae_coex_app
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: WISECONNECT RSI_SAMPLE_HAL RSI_DEBUG_PRINTS RSI_WLAN_ENABLE RSI_SPI_INTERFACE USE_HAL_DRIVER STM32F411xE RSI_DEBUG_PRINTS RSI_SPI_HIGH_SPEED_ENABLE RSI_BLE_ENABLE RSI_WITH_OS RSI_WLAN_API_ENABLE RSI_CRYPTO_ENABLE
  c misc: --C99 --reduce_paths
  c include: ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app;../../../../../sapi/include; ../../../../../sapi/network/protocols; ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/ble; ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/inc; ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/user_input; ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/utils; ../../../../../platforms/stm32/drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../platforms/stm32/drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../platforms/stm32/drivers/CMSIS/Include; ../../../../../platforms/stm32/drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../platforms/stm32/core/inc; ../../../../../platforms/stm32/boards/nucleo-f411re; ../../../../../third_party/freertos/include; ../../../../../third_party/freertos/portable; ../../../../../sapi/rtos/freertos_wrapper; ../../../../../sapi/network/protocols; platforms/stm32/boards/nucleo-f411re
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329 --reduce_paths
  group example
    ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/: main.c root_auto_gen.c btc_auto_gen.c
    ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/ble/: ble_cmd_hdlr_auto_gen.c ble_event_hdlr_auto_gen.c ble_task.c ble_ui_cmd_hdlr.c ble_user_cmd.c ble_user_event_hdlrs.c ble_config.h ble_cmd_hdlr_auto_gen.h ble_event_hdlr_auto_gen.h ble_private.h
    ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/user_input/: rsi_user_input_DEMO_x.c rsi_user_input_DEMO_x.h
    ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/utils/: command_parser.c event_loop.c rsi_common_utils.c generic_command_handling.h rsi_common_utils.h event_loop.h
    ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/wlan/: rsi_wlan_tcp_server_app.c
    ../../../../../examples/snippets/wlan_ble/wlan_ble_ae_coex_app/inc/: rsi_ble_config.h rsi_bt_config.h rsi_common_app.h rsi_wlan_config.h
  group platform/stm32
    ../../../../../platforms/stm32/hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_hal_mcu_rtc.c sl_hal_mcu_logging.c
    ../../../../../platforms/stm32/drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../../../../../platforms/stm32/core/src/: system_stm32f4xx.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../../../../../platforms/stm32/core/startup/: startup_stm32f411xe.s
  group platform/nucleo-f411re
    ../../../../../platforms/stm32/boards/nucleo-f411re/: rsi_board_configuration.h
  group sapi/core
    ../../../../../sapi/common/: rsi_common_apis.c rsi_device_init_apis.c rsi_apis_rom.c rsi_apis_non_rom.c
    ../../../../../sapi/crypto/: rsi_crypto.c
    ../../../../../sapi/driver/: rsi_iap.c rsi_device_init.c rsi_queue.c rsi_common.c rsi_os_none.c rsi_driver_event_handlers.c rsi_scheduler.c rsi_bt_ble.c rsi_utils.c rsi_driver.c rsi_events.c rsi_timer.c rsi_setregion_countryinfo.c rsi_pkt_mgmt.c rsi_utils_rom.c rsi_pkt_mgmt_rom.c rsi_scheduler_rom.c rsi_queue_rom.c rsi_events_rom.c rsi_nwk.c rsi_wlan.c
    ../../../../../sapi/driver/device_interface/sdio/: rsi_sdio_mem_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_frame_rd_wr.c rsi_sdio_reg_rd_wr.c
    ../../../../../sapi/driver/device_interface/spi/: rsi_spi_reg_rd_wr.c rsi_spi_frame_rd_wr.c rsi_spi_iface_init.c rsi_spi_functs.c rsi_spi_mem_rd_wr.c
    ../../../../../sapi/driver/device_interface/uart/: rsi_uart.c
    ../../../../../sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
    ../../../../../sapi/wlan/: rsi_wlan_apis.c
  group sapi/bluetooth
    ../../../../../sapi/bluetooth/: rsi_bt_spp_apis.c rsi_bt_gap_apis.c rsi_ble_gap_apis.c rsi_bt_common_apis.c rsi_ble_gatt_apis.c rsi_bt_avrcp_apis.c rsi_bt_a2dp_apis.c
  group sapi/freertos
    ../../../../../sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c port.c portmacro.h
  group third_party/freertos
    ../../../../../third_party/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/MemMang/: heap_4.c
  group sapi/sockets
    ../../../../../sapi/network/protocols/: rsi_dns.c rsi_emb_mqtt_client.c rsi_raw_data.c rsi_http_ota_fw_up.c rsi_dhcp_user_class.c
